# Keil uVision project NCD_Tester.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NCD_Tester +hex
  AfterMake: D:\Program Files\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\AppLunch;..\COM;..\Datas;..\Function;..\HardwareDriver;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Task;..\ThirdParty\Fatfs\src;..\ThirdParty\lwip-1.4.1\src\include;..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\ThirdParty\lwip-1.4.1\src\include\netif;..\ThirdParty\lwip-1.4.1\src\include\lwip;..\ThirdParty\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\ThirdParty\lwip-1.4.1\port\STM32F4x7;..\ThirdParty\lwip-1.4.1\User;..\ThirdParty\cJSON-master;..\UI;..\ThirdParty\FreeRTOS\inc;..\Daos;..\Entity;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../AppLunch/: main.c SystemInit.c stm32f4xx_it.c
  group Drivers
    ../HardwareDriver/: Iwdg_Driver.c Led_Driver.c Timer3_Driver.c Timer4_Driver.c Usart1_Driver.c Usart2_Driver.c Usart3_Driver.c Usart4_Driver.c CardCheck_Driver.c Usart5_Driver.c Usart6_Driver.c CodeScanner_Driver.c Motor1_Driver.c Motor2_Driver.c Motor3_Driver.c Motor4_Driver.c
  group Functions
    ../Function/: CodeScanFunction.c Paidui_Fun.c Printf_Fun.c ReadBarCode_Fun.c Universal_Fun.c Motor1_Fun.c Motor2_Fun.c Motor3_Fun.c Motor4_Fun.c
  group Tasks
    ../Task/: CodeScan_Task.c Iwdg_Task.c SystemStart_Task.c Universal_Task.c
  group Entity
    ../Entity/: DateTime.h Define.h ItemConstData.h PaiduiUnitData.h QRCode.h Temperature.h Motor.h
  group DataS
    ../Datas/: ItemConst_Data.c System_Data.c QRCode_Data.c Motor_Data.c
  group COM
    ../COM/: CRC_CCITT.c CRC16.c Delay.c Md5.c MyEncryptTool.c MyLock.c MyMem.c MyTools.c QueueUnits.c Timer.c
  group FreertOS
    ../ThirdParty/FreeRTOS/src/: heap_4.c list.c port.c queue.c tasks.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Doc
    ../DOC/: README.txt
