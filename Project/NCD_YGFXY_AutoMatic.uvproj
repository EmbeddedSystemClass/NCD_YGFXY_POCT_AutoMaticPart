# Keil uVision project NCD_YGFXY_AutoMatic.uvproj, settings and files
target NCD_YGFXY_AutoMatic (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NCD_YGFXY_AutoMatic
  AfterMake: D:\Program Files\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\AppLunch;..\COM;..\Datas;..\Function;..\HardwareDriver;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Task;..\ThirdParty\Fatfs\src;..\ThirdParty\lwip-1.4.1\src\include;..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\ThirdParty\lwip-1.4.1\src\include\netif;..\ThirdParty\lwip-1.4.1\src\include\lwip;..\ThirdParty\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\ThirdParty\lwip-1.4.1\port\STM32F4x7;..\ThirdParty\lwip-1.4.1\User;..\ThirdParty\cJSON-master;..\UI;..\ThirdParty\FreeRTOS\inc;..\Daos;..\Entity;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../AppLunch/: stm32f4xx_it.c main.c SystemInit.c
  group Drivers
    ../HardwareDriver/: CardCheck_Driver.c CodeScanner_Driver.c Iwdg_Driver.c Led_Driver.c Motor1_Driver.c Motor2_Driver.c Motor3_Driver.c Motor4_Driver.c Timer3_Driver.c Usart1_Driver.c Usart2_Driver.c Usart3_Driver.c Usart4_Driver.c Usart5_Driver.c Usart6_Driver.c SDIO_Driver.c stm324x7i_eval_sdio_sd.c Channel_Driver.c ADS8325_Driver.c DA_Driver.c RX8025_Driver.c LCD_Driver.c LedCheck_Driver.c
  group Functions
    ../Function/: CodeScanFunction.c Motor1_Fun.c Motor2_Fun.c Motor3_Fun.c Motor4_Fun.c Paidui_Fun.c Printf_Fun.c ReadBarCode_Fun.c Universal_Fun.c SelfTest_Fun.c LCDInputFun.c
  group Tasks
    ../Task/: CodeScan_Task.c Iwdg_Task.c SystemStart_Task.c Universal_Task.c LcdInput_Task.c SystemUI_Task.c
  group UI
    ../UI/: LunchPage.c WelcomePage.c
  group Entitys
    ../Entity/: DateTime.h Define.h ItemConstData.h Motor.h PaiduiUnitData.h QRCode.h Temperature.h Device.h NetWork.h DeviceAdjust.h DeviceError.h DeviceMaintenance.h DeviceQuality.h Operator.h RemoteSoftInfo.h ReTestData.h TestData.h AdjustData.h
  group Datas
    ../Datas/: ItemConst_Data.c Motor_Data.c QRCode_Data.c System_Data.c SystemSet_Data.c UI_Data.c MyTest_Data.c
  group Daos
    ../Daos/: AppFileDao.c DeviceAdjustDao.c DeviceDao.c DeviceErrorDao.c DeviceMaintenanceDao.c DeviceQualityDao.c RecordDataDao.c RemoteSoftDao.c SystemSet_Dao.c TestDataDao.c
  group LwipUser
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../ThirdParty/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
    ../ThirdParty/lwip-1.4.1/User/: netconf.c stm32f4x7_eth_bsp.c
    ../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
  group Com
    ../COM/: CRC_CCITT.c CRC16.c Delay.c Md5.c MyEncryptTool.c MyLock.c MyMem.c MyTools.c QueueUnits.c Timer.c MyStack.c Intent.c
  group Freertos
    ../ThirdParty/FreeRTOS/src/: heap_4.c list.c port.c queue.c tasks.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group ST_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Fatfs
    ../ThirdParty/Fatfs/src/: diskio.c ff.c
    ../ThirdParty/Fatfs/src/option/: syscall.c
  group Lwip_1.4.1
    ../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
