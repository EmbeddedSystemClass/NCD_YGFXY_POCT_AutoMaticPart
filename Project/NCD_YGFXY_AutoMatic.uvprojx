# Keil uVision project NCD_YGFXY_AutoMatic.uvprojx, settings and files
target NCD_YGFXY_AutoMatic (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NCD_YGFXY_AutoMatic +hex
  AfterMake: D:\Program Files\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\AppLunch;..\COM;..\Datas;..\Function;..\HardwareDriver;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Task;..\ThirdParty\Fatfs\src;..\ThirdParty\lwip-1.4.1\src\include;..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\ThirdParty\lwip-1.4.1\src\include\netif;..\ThirdParty\lwip-1.4.1\src\include\lwip;..\ThirdParty\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\ThirdParty\lwip-1.4.1\port\STM32F4x7;..\ThirdParty\lwip-1.4.1\User;..\ThirdParty\cJSON-master;..\UI;..\Daos;..\Entity;..\Libraries\CMSIS\Include;..\ThirdParty\FreeRTOS\Source\include;..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../AppLunch/: main.c stm32f4xx_it.c SystemInit.c
  group Drivers
    ../HardwareDriver/: ADS8325_Driver.c CardCheck_Driver.c Channel_Driver.c CodeScanner_Driver.c DA_Driver.c Iwdg_Driver.c LCD_Driver.c Led_Driver.c LedCheck_Driver.c Motor1_Driver.c Motor2_Driver.c Motor4_Driver.c RX8025_Driver.c TempleteFile.c Timer3_Driver.c Usart1_Driver.c Usart2_Driver.c Usart3_Driver.c Usart4_Driver.c Usart5_Driver.c Usart6_Driver.c Ceju_Driver.c SD_SPI_Driver.c
  group Functions
    ../Function/: CodeScanFunction.c LCDInputFun.c Motor1_Fun.c Motor2_Fun.c Motor4_Fun.c Paidui_Fun.c Printf_Fun.c ReadBarCode_Fun.c SelfTest_Fun.c Test_Fun.c Universal_Fun.c Motor_Fun.c
  group Tasks
    ../Task/: CodeScan_Task.c Iwdg_Task.c LcdInput_Task.c Paidui_Task.c SystemStart_Task.c SystemUI_Task.c Test_Task.c Universal_Task.c LwipCom_Task.c LwipDHCP_Task.c Motor_Task.c BasicWEB_Task.c
  group UI
    ../UI/: WelcomePage.c LunchPage.c SelectUserPage.c SystemSetPage.c UserMPage.c SampleIDPage.c WaittingCardPage.c PreReadCardPage.c PaiDuiPage.c TimeDownNorPage.c TestPage.c AboutUsPage.c RecordPage.c ShowResultPage.c OtherSetPage.c NetPreSetPage.c NetSetPage.c ServerSetPage.c NetInfoPage.c ShowDeviceInfoPage.c SetDeviceInfoPage.c SetDeviceIDPage.c ReTestPage.c MaintenancePage.c MaintenanceRecordPage.c AdjustRecordPage.c ErrorRecordPage.c QualityDetailPage.c QualityRecordPage.c QualityPage.c SleepPage.c
  group Entitys
    ../Entity/: DateTime.h Define.h Device.h DeviceAdjust.h DeviceError.h DeviceMaintenance.h DeviceQuality.h ItemConstData.h Motor.h NetWork.h Operator.h PaiduiUnitData.h QRCode.h RemoteSoftInfo.h Temperature.h TestData.h
  group Datas
    ../Datas/: ItemConst_Data.c Motor_Data.c MyTest_Data.c RemoteSoft_Data.c System_Data.c SystemSet_Data.c UI_Data.c Maintenance_Data.c Quality_Data.c
  group Daos
    ../Daos/: AppFileDao.c DeviceDao.c RecordDataDao.c RemoteSoftDao.c SystemSet_Dao.c TestDataDao.c ReTestDataDao.c DeviceMaintenanceDao.c DeviceAdjustDao.c DeviceErrorDao.c DeviceQualityDao.c
  group LwipUser
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../ThirdParty/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
    ../ThirdParty/lwip-1.4.1/User/: netconf.c stm32f4x7_eth_bsp.c
    ../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
  group Com
    ../COM/: CRC_CCITT.c CRC16.c Delay.c Intent.c Md5.c MyEncryptTool.c MyLock.c MyMem.c MyStack.c MyTools.c QueueUnits.c Timer.c
  group Freertos
    ../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c
    ../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group ST_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group Fatfs
    ../ThirdParty/Fatfs/src/: ff.c diskio.c
    ../ThirdParty/Fatfs/src/option/: syscall.c
  group Lwip_1.4.1
    ../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
